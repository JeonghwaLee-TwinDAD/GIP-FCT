# IAR project NUCLEO-G070RB.ewp, settings and files
configuration COORD_868 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx; DEVICE_TYPE_COORD; RF_IS_868; NDEBUG
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../G3_Applications; ../User_Applications/Inc; ../User_Applications/Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: NUCLEO-G070RB_coord_868.hex
  ILINK.IlinkOutputFile: NUCLEO-G070RB.out
  ILINK.IlinkIcfFile: stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration COORD_915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx; DEVICE_TYPE_COORD; RF_IS_915; NDEBUG
  OBJCOPY.OOCOutputFile: NUCLEO-G070RB_coord_915.hex
configuration DEVICE_868 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx; DEVICE_TYPE_DEVICE; RF_IS_868; NDEBUG
  OBJCOPY.OOCOutputFile: NUCLEO-G070RB_device_868.hex
configuration DEVICE_915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx; DEVICE_TYPE_DEVICE; RF_IS_915; NDEBUG
  OBJCOPY.OOCOutputFile: NUCLEO-G070RB_device_915.hex
  group Application/EWARM
    ./: startup_stm32g070xx.s
  group Application/G3_Applications
    ../G3_Applications/: g3_app_attrib_tbl.c g3_app_attrib_tbl.h g3_app_boot.c g3_app_boot.h g3_app_boot_tbl.c g3_app_boot_tbl.h g3_app_config.c g3_app_config.h g3_app_keep_alive.c g3_app_keep_alive.h g3_app_pansort.c g3_app_pansort.h g3_hif.c g3_hif.h g3_msg_id.h g3_task.c g3_task.h hi_adp_lbp_message_catalog.h hi_adp_loadng_message_catalog.h hi_adp_pib_attributes.h hi_adp_pib_types.h hi_adp_sap_interface.h hi_boot_sap_interface.h hi_g3lib_attributes.h hi_g3lib_sap_interface.h hi_g3lib_trace_modules.h hi_ip_pib_attributes.h hi_ip_pib_types.h hi_ip_sap_interface.h hi_mac_constants.h hi_mac_message_catalog.h hi_mac_pib_attributes.h hi_mac_pib_types.h hi_msgs_impl.c hi_msgs_impl.h hi_phy_support.h hif_g3_common.h
  group Application/User
    ../Src/: app_freertos.c crc.c gpio.c main.c mem_pool.c soft_timer.c st8500_handler.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c stm32g0xx_it.c task_comm.c timed_events.c usart.c utils.c
    ../Inc/: crc.h mem_pool.h soft_timer.h st8500_handler.h task_comm.h timed_events.h utils.h
  group Application/User_Applications
    ../User_Applications/Src/: user_g3_common.c user_if_fsm.c user_task.c user_term_rxtx.c
    ../User_Applications/Inc/: user_g3_common.h user_if_fsm.h user_task.h user_term_rxtx.h
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
